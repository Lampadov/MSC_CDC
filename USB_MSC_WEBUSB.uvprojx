# Keil uVision project USB_MSC_WEBUSB.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_MSC_WEBUSB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU
  c include: .\examples\msc-webusb;.\src\class\msc;.\src\class\vendor;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Example
    ./examples/msc-webusb/: main.c usb_descriptors.c msc_disk.c disk_image.c
  group TinyUSB
    ./src/class/msc/: msc_device.c
    ./src/class/vendor/: vendor_device.c
    ./src/common/: tusb_fifo.c
    ./src/device/: usbd.c
    ./src/typec/: usbc.c
    ./src/: tusb.c tusb_mdr32fxqi.c
software components: Device:Startup 2.2.0i, Drivers:ADC 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:USB 2.1.0i
