# Keil uVision project USB_EXAMPLES.uvprojx, settings and files
target CDC_ONLY (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_CDC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_CDC
  c misc: --diag_suppress=66
  c include: .\examples\cdc-only;.\src\class\cdc\serial;.\src\class\cdc;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Example
    ./examples/: example_main.c example_usb_descriptors.c example_msc_disk.c example_disk_image.c
  group TinyUSB
    ./src/class/cdc/: cdc_device.c
    ./src/class/msc/: msc_device.c
    ./src/class/hid/: hid_device.c
    ./src/class/vendor/: vendor_device.c
    ./src/common/: tusb_fifo.c
    ./src/device/: usbd.c
    ./src/typec/: usbc.c
    ./src/: tusb.c tusb_mdr32fxqi.c
target HID_MOUSE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_HID_MOUSE +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_HID
  c misc: --diag_suppress=66
  c include: .\examples\hid-only;.\src\class\hid;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target HID_KEYBOARD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_HID_KEYBOARD +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_HID,HID_MODE=2
  c misc: --diag_suppress=66
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MSC_ONLY (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_MSC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_MSC
  c misc: --diag_suppress=66
  c include: .\examples\msc-only;.\src\class\msc;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target WEBUSB_ONLY (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_WEBUSB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_WEBUSB_ONLY
  c misc: --diag_suppress=66
  c include: .\examples\webusb-only;.\src\class\vendor;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MSC_HID (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_MSC_HID +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_MSC_HID
  c misc: --diag_suppress=66
  c include: .\examples\msc-hid;.\src\class\msc;.\src\class\hid;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MSC_WEBUSB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: as above
  output: USB_MSC_WEBUSB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU,EXAMPLE_MSC_WEBUSB
  c misc: --diag_suppress=66
  c include: .\examples\msc-webusb;.\src\class\msc;.\src\class\vendor;.\src\common;.\src\device;.\src\osal;.\src\typec;.\src;.\src\bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: Device:Startup 2.2.0i, Drivers:ADC 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:USB 2.1.0i
